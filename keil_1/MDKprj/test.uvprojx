# Keil uVision project test.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ../: code_def.c lcd.c main.c systick.c gpio.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.1
